options:
  parameters:
    author: UWE-4 Demod
    comment: UWE-4 FSK 9600 AX.25 Demodulator for IQ
    generate_options: qt_gui
    id: UWEiq
    output_language: python
    title: UWE-4 FSK 9600 IQ Demod
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '57600'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / baud_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / (2 * 3.14159 * 2400)
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\demodulation\UWEIQ\UWEiq.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\demodulation\UWEIQ\iq_14011420_435599000_57600.raw
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25 * 0.175 * 0.175
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '15'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name='NRZI Decoder',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.last = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              for i in range(len(inp)):
                  current = inp[i] & 1
                  if current == self.last:
                      out[i] = 1
                  else:
                      out[i] = 0
                  self.last = current
              return len(out)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os

      class blk(gr.sync_block):
          def __init__(self, file_name='output.hex'):
              gr.sync_block.__init__(self, name='PDU to Hex File', in_sig=None, out_sig=None)
              self.file_name = file_name
              self.message_port_register_in(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('pdus'), self.handle_msg)
              with open(self.file_name, 'w') as f:
                  pass

          def handle_msg(self, msg):
              if pmt.is_pdu(msg):
                  data = pmt.cdr(msg)
                  bytes_data = pmt.u8vector_elements(data)
                  hex_str = ' '.join(f'{b:02X}' for b in bytes_data)
                  with open(self.file_name, 'a') as f:
                      f.write(hex_str + '\n')
    file_name: '"D:\\demodulation\\UWEIQ\\UWEiq.hex"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '7500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: Bits After Slicer
    size: '1024'
    srate: '9600'
    type: float
    ymax: '1.2'
    ymin: '-0.2'
    yunit: ''
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: ''
    size: '1024'
    srate: 1e5
    type: float
    yunit: ''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '100000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_descrambler_bb_0, '0', epy_block_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_0, print]
- [digital_hdlc_deframer_bp_0, out, epy_block_1, pdus]
- [digital_hdlc_deframer_bp_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, '0', digital_hdlc_deframer_bp_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
